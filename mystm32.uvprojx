# Keil uVision project mystm32.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mystm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\STM32_USB_Device_Driver;.\Mass_Storage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c mylib.h myLED.c my7Segment.c my1602.c myUSART_INT.c myUSART.c myI2C.c mySoftI2C.c mySPI_OLED.h mySPI_OLED.c mySPI_Flash.c myFatFs.c myNVIC.c myDMA.c myADC.c mySYSTICK.c myTIM_BASE.c myTIM_PWMOUT.c myTIM_TouchButton.c myButtonArray.c myIWDG.c myWWDG.c myUSB.c myESP8266.c myEXTI_IR.c
    Resource/: res.c
  group Resource
    ./Resource/: music.pcm
  group FatFs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h ffunicode.c
  group SDCard
    ./SDCard/: mySD_SDIO.h mySD_SDIO.c
  group USB_MSC
    ./Mass_Storage/: usb_scsi.h usb_scsi.c usb_pwr.h usb_pwr.c usb_prop.h usb_prop.c usb_istr.h usb_istr.c usb_endp.c usb_desc.h usb_desc.c usb_conf.h usb_bot.h usb_bot.c stm32l1xx_conf.h stm32f10x_conf.h stm32_it.h scsi_data.c platform_config.h nand_if.h nand_if.c memory.h memory.c mass_mal.h mass_mal.c hw_config.h hw_config.c fsmc_nand.h fsmc_nand.c
  group USB_CORE
    ./STM32_USB_Device_Driver/: otgd_fs_cal.c otgd_fs_cal.h otgd_fs_dev.c otgd_fs_dev.h otgd_fs_int.c otgd_fs_int.h otgd_fs_pcd.c otgd_fs_pcd.h otgd_fs_regs.h usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
software components: CMSIS:CORE 5.1.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
