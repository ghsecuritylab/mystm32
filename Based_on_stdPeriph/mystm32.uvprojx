# Keil uVision project mystm32.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mystm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c mylib.h myLED.c my7Segment.c my1602.c myUSART_INT.c myUSART.c myI2C.c mySoftI2C.c mySPI_OLED.h mySPI_OLED.c mySPI_Flash.c myFatFs.c myNVIC.c myDMA.c myADC.c mySYSTICK.c myTIM_BASE.c myTIM_PWMOUT.c myTIM_TouchButton.c myButtonArray.c myIWDG.c myWWDG.c myEXTI_IR.c myNRF24L01.c myStepperMotor.c myESP8266.c myBluetooth.c myATGM336H.c
    Resource/: res.c
  group Resource
    ./Resource/: music.pcm
  group FatFs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h ffunicode.c
software components: CMSIS:CORE 5.1.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
