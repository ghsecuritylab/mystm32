# Keil uVision project Project.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HID_KEYBOARD
  c misc: --C99
  c include: ./Inc;../../../CMSIS/STM32F1xx/Include;../../../STM32F1xx_HAL_Driver/Inc;../../../BSP/;../../../Middlewares/STM32_USB_Device_Library/Core/Inc;../../../Middlewares/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ./Src/: stm32f1xx_it.c main.c usbd_conf.c usbd_desc.c
  group BSP
    ../../../BSP/: f103_usart.c
  group CMSIS
    ./Src/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../../../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../Middlewares/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
software components: CMSIS:CORE 5.1.1
