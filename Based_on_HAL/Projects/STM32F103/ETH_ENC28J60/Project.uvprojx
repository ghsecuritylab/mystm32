# Keil uVision project Project.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ./Inc;../../../CMSIS/STM32F1xx/Include;../../../STM32F1xx_HAL_Driver/Inc;../../../BSP/;..\..\..\Middlewares\LwIP\src\include;..\..\..\Middlewares\LwIP\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ./Src/: stm32f1xx_it.c main.c app_ethernet.c ethernetif.c tcp_echoclient.c tcp_echoserver.c udp_echoclient.c udp_echoserver.c
  group BSP
    ../../../BSP/: stm3210e_eval.c
  group CMSIS
    ./Src/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../../../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Middlewares/lwIP/Netif
    ../../../Middlewares/LwIP/src/netif/: ethernet.c
  group Middlewares/lwIP/Core/IPv4
    ../../../Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwIP/Core
    ../../../Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/lwIP/Api
    ../../../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
software components: CMSIS:CORE 4.1.0
