# Keil uVision project Project.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,SD_MODE_SPI
  c include: .\Inc;..\..\..\BSP;..\..\..\CMSIS\STM32F1xx\Include;..\..\..\STM32F1xx_HAL_Driver\Inc;..\..\..\Middlewares\FatFs;..\..\..\Middlewares\FatFs\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/Src
    ./Src/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group BSP
    ../../../BSP/: f103_sd_sdio.c f103_sd_spi.c f103_spi.c f103_usart.c
  group Application/Startup
    ../../../CMSIS/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Driver/HAL
    ../../../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Middleware/FatFs
    ../../../Middlewares/FatFs/: diskio.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
    ../../../Middlewares/FatFs/drivers/: sd_diskio.c
software components: CMSIS:CORE 5.1.1
