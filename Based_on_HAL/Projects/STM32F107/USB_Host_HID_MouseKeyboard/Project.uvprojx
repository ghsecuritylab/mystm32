# Keil uVision project Project.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ./Inc;../../../CMSIS/STM32F1xx/Include;../../../STM32F1xx_HAL_Driver/Inc;../../../BSP/;..\..\..\Middlewares\STM32_USB_Host_Library\Core\Inc;..\..\..\Middlewares\STM32_USB_Host_Library\Class\HID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ./Src/: stm32f1xx_it.c main.c keyboard.c menu.c mouse.c system_stm32f1xx.c usbh_conf.c
  group BSP
    ../../../BSP/: stm3210c_eval.c stm3210c_eval_io.c
  group CMSIS
    ./Src/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../../../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_spi_ex.c stm32f1xx_ll_usb.c
  group Application/MDK-ARM
    ../../../CMSIS/STM32F1xx/Source/Templates/arm/: startup_stm32f107xc.s
  group Middlewares/USBH/Core
    ../../../Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/USBH/Class/HID
    ../../../Middlewares/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_parser.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c
software components: CMSIS:CORE 5.1.1
